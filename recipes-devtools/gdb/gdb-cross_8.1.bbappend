include gdb-8.1-ilp32.inc
