EXTRA_OECONF_append_aarchilp32 = " --disable-assembly "
