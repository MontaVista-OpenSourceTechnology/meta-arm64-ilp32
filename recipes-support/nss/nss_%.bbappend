do_compile_prepend_aarchilp32 () {
export NSS_ENABLE_WERROR=0
export NSS_DISABLE_CHACHAPOLY=1
}
